<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\generic_app_stm32G030K8Tx.ewp</path>
  </project>
  <batchBuild />
</workspace>
